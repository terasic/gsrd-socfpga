require gsrd-console-image.bb

export IMAGE_BASENAME = "gsrd_sdcard_console"
BOOT_MEDIUM = "sdmmc"
