require gsrd-console-image.bb

export IMAGE_BASENAME = "gsrd_emmc_console"
BOOT_MEDIUM = "emmc"
