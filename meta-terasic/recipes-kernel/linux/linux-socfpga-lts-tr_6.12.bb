LINUX_VERSION = "6.12.43"
LINUX_VERSION_SUFFIX = "-lts"

LIC_FILES_CHKSUM = "file://COPYING;md5=6bc538ed5bd9a7fc9398086aedcd7e46"

SRCREV = "6f1e9c1b70c9251436fdd0f52cb89e3d965b2b3f"

include linux-socfpga.inc
