require arm-trusted-firmware.inc

LIC_FILES_CHKSUM = "file://docs/license.rst;md5=6ed7bace7b0bc63021c6eba7b524039e"

ATF_VERSION = "v2.13.1"

SRCREV = "0ba6510706b21ac664c4dcc091e48362bbceab6f"
