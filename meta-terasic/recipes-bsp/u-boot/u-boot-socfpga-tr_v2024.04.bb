require u-boot-socfpga-common.inc

UBOOT_VERSION = "v2024.04"

SRCREV = "c0d1bd1f379e493e5251b00c4aac2a017e26c14d"
