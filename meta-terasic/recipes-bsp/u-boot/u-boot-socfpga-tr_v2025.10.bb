require u-boot-socfpga-common.inc

LIC_FILES_CHKSUM = "file://Licenses/README;md5=2ca5f2c35c8cc335f0a19756634782f1"

UBOOT_VERSION = "v2025.10"

SRCREV = "867be2a9cd1501b38b0ad14f9e462ab89a4361b8"
